CFLAGS_append_kirkstone = " -mfloat-abi=hard -mcpu=cortex-a7 "
CFLAGS_remove_aarch64_kirkstone = " -mfloat-abi=hard -mcpu=cortex-a7 "

