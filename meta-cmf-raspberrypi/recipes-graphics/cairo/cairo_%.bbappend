#Original license mentioned in openembedded cairo 1.16 base recipe "LICENSE_${PN}-gobject = "MPL-1.1 | LGPLv2.1" is not getting applied for multilib
#This can be corrected by replacing ${PN} with ${BPN} without modifying the license
LICENSE_${BPN}-gobject = "MPL-1.1 | LGPLv2.1"
