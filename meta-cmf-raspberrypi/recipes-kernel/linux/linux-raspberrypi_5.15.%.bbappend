FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_broadband = " file://kernel_5_15_kirkstone.cfg"
