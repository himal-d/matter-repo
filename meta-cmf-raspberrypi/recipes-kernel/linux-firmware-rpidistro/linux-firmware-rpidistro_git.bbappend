SRC_URI_remove = "git://github.com/RPi-Distro/firmware-nonfree;branch=master;protocol=https"
SRC_URI_dunfell += "git://github.com/RPi-Distro/firmware-nonfree;branch=buster;protocol=https"
