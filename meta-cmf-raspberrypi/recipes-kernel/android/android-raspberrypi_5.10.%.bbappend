FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0002-bluetooth-refactor-malicious-adv-data-check.patch"
