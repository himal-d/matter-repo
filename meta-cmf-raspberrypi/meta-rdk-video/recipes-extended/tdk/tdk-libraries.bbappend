PACKAGE_TYPE = "OSS"

EXTRA_OEMAKE_append = " MFRHAL_LIBS+="$(MFRHAL_LIBS) -lRDKMfrLib " "
