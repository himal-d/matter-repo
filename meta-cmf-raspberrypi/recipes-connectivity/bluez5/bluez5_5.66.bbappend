FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_remove = "file://0004-Move-the-43xx-firmware-into-lib-firmware.patch"
SRC_URI += "file://Move-the-43xx-firmware-into-lib-firmware.patch"

