CFLAGS_append_aarch64_kirkstone =" -Wno-error=incompatible-pointer-types "

