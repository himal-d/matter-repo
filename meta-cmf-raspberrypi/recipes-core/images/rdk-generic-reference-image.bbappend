# LG cobalt launcher component
IMAGE_INSTALL_append = " cobalt-launcher"

